# Keil uVision project UART_UseLib.uvproj, settings and files
target UART_UseLib (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: UART_UseLib
  c flags: Optim=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c include: C:\ti\TivaWare\driverlib;C:\ti\TivaWare\inc;C:\ti\TivaWare;..\BAI07_UART_UseLib;.\Library
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Start Up
    ./: startup_TM4C123.s
  group Main
    ./: main.c
  group Library
    C:/ti/TivaWare/driverlib/rvmdk/: driverlib.lib
  group UART_Lib
    ./Library/: Uart_lib.c
